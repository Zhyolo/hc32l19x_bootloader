# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (6130001::V6.13.1::.\ARMCLANG)
  device: HC32L196KCTA HDSC
  pack: HDSC.HC32L19X.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 wLevel=4
  c include: ..\application;..\driver\inc;..\mcu\common;..\midware\Ymodem
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group application
    ../application/: main.c flash_update.c
  group common
    ../mcu/common/: interrupts_hc32l19x.c system_hc32l19x.c
    ../mcu/MDK/: startup_hc32l19x.s
  group driver
    ../driver/src/: crc.c ddl.c flash.c gpio.c sysctrl.c uart.c
software components: CMSIS:CORE 5.4.0
